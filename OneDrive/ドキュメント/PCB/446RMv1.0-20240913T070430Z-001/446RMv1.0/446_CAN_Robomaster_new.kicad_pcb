# Repository kiri0110/can_test

## KiCad design OneDrive/ドキュメント/PCB/446RMv1.0-20240913T070430Z-001/446RMv1.0/446_CAN_Robomaster_new.kicad_pcb

Board: 2 copper layers, 72.4 x 47.3 mm, 80 parts (40 on the bottom side), 63 nets.

Parts:
C1, C2: 4.3p; C_0603_1608Metric
C3: 1u; C_0603_1608Metric
C4, C5, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16: 0.1u; C_0603_1608Metric
C6: 4.7u; C_0603_1608Metric
C17: 0.01u; C_0603_1608Metric
C18: 0.22u; C_0603_1608Metric
D1: USR0; LED_0603_1608Metric
D2: USR1; LED_0603_1608Metric
D3: 5VPWR; LED_0603_1608Metric
D4: USR2; LED_0603_1608Metric
D5, D7: CUHS20S30; D_TUMD2
D6: LED1; LED_0603_1608Metric
D8: PC6; LED_0603_1608Metric
D9: PC8; LED_0603_1608Metric
FB1: FerriteBead; L_0603_1608Metric
H1, H2, H3, H4: H; MountingHole_3.2mm_M3_DIN965_Pad
J1: ENC0; JST_XA_B05B-XASK-1_1x05_P2.50mm_Vertical
J2: ST-Link; JST_GH_SM08B-GHS-TB_1x08-1MP_P1.25mm_Horizontal
J3: UART3; JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical
J4: 5V_IO; JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical
J8: CAN1A; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal_Handsolder
J9: CAN1B; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal_Handsolder
J10: CAN0A; Kai_LAN_RJ45_Neltron_Industrial_7810-8P8C
J11: CAN0B; Kai_LAN_RJ45_Neltron_Industrial_7810-8P8C
J12: Int0; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J13: Motor0; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J14: PA11; JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical
J15: I2C_LCD; PinSocket_1x04_P2.54mm_Vertical
J16: Int1; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J17: PA12; JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical
JP1: 5V_I2C; solderbridge
JP2: 3v3_I2C; solderbridge
LS1: UGCT7525AN4
Q1: 2N7002K; SOT-23
R1: 1k5; R_0603_1608Metric
R2, R6, R8: 10k; R_0603_1608Metric
R3: 5.1k; R_0603_1608Metric
R4: 2.4k; R_0603_1608Metric
R5, R13: 120R; R_0603_1608Metric
R7, R17: 510R; R_0603_1608Metric
R9, R10, R12: 1k; R_0603_1608Metric
R11: 3.3k; R_0603_1608Metric
R14: 2.2k; R_0603_1608Metric
R15: 200R; R_0603_1608Metric
R16: 3k3; R_0603_1608Metric
SW1: UnitSelect; SW_DIP_SPSTx04_Slide_KingTek_DSHP04TS_W7.62mm_P1.27mm
SW2: BOOT0; SW_SPST_PTS810_HandSolder
SW3: NRST; SW_SPST_PTS810_HandSolder
SW4: USR2; SW_SPST_PTS810_HandSolder
SW5: USR1; SW_SPST_PTS810_HandSolder
SW6: USR0; SW_SPST_PTS810_HandSolder
SW7: CAN_END0; slide_SW
U1: STM32F446RETx; LQFP-64_10x10mm_P0.5mm
U2: USB_5V; aki_USB_mB_PWR
U3: NJM12788F33; SOT-23-5
U4, U5: MCP2561-E/SN; SOIC8-N_MC_MCH
Y1: ABS25-32.768KHZ-6-T; ABS2532768KHZT

Connections:
5V_CAN0: C14.1, C15.2, C16.2, D3.2 (A), D5.1 (K), D7.1 (K), J1.4, J2.2, J4.2, J10.7, J10.8, J11.7, J11.8, J12.2, J16.2, JP1.2 (B), LS1.1, U3.1 (VIN), U3.3 (CONTROL), U4.3 (VDD), U5.3 (VDD)
+3.3VA: C9.1, FB1.2, U1.13 (VDDA)
+3V3: C3.2, C4.1, C5.2, C7.1, C8.1, C18.1, FB1.1, JP2.2 (B), R1.1, SW2.1, U1.1 (VBAT), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U3.5 (VOUT)
BOOT0: R8.2, SW2.2, U1.60 (BOOT0)
BUZZER: R15.1, U1.43 (PA10)
CAN_0+: J10.1, J11.1, SW7.2 (B), U4.7 (CANH)
CAN_0-: J10.2, J11.2, R13.2, U4.6 (CANL)
CAN_1+: J8.2, J9.2, R5.1, U5.7 (CANH)
CAN_1-: J8.1, J9.1, SW1.4, U5.6 (CANL)
CAN_RD_0: U1.61 (PB8), U4.4 (RXD)
CAN_RD_1: U1.33 (PB12), U5.4 (RXD)
CAN_TD_0: U1.62 (PB9), U4.1 (TXD)
CAN_TD_1: U1.34 (PB13), U5.1 (TXD)
ENC0A_PA1: J1.3, U1.15 (PA1)
ENC0B_PA0: J1.5, U1.14 (PA0)
GND: C1.2, C2.2, C3.1, C4.2, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.1, C16.1, C17.2, C18.2, D1.1 (K), D2.1 (K), D4.1 (K), D6.1 (K), D8.1 (K), D9.1 (K), H1.1, H2.1, H3.1, H4.1, J1.1, J2.1, J4.1, J10.4, J10.5, J11.4, J11.5, J12.1, J13.1, J14.1, J15.1, J16.1, J17.1, Q1.2 (S), R2.2, R3.1, R4.1, R6.1, R8.1, R10.2, R14.1, SW3.2, SW4.2, SW5.2, SW6.2, U1.12 (VSSA), U1.18 (VSS), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS), U2.2 (GND), U2.3 (Shield), U3.2 (GND), U4.2 (VSS), U4.8 (STBY), U5.2 (VSS), U5.8 (STBY)
GPIO_PA11: J14.2, U1.44 (PA11)
GPIO_PA12: J17.2, U1.45 (PA12)
I2C2_SCL: J15.3, U1.29 (PB10)
I2C2_SDA: J15.2, U1.53 (PC12)
INT0: J12.3, U1.25 (PC5)
INT1: J16.3, U1.20 (PA4)
LED1: R12.1, U1.21 (PA5)
Motor0CCW_PC8: J13.3, R17.1, U1.39 (PC8)
Motor0CW_PC6: J13.2, R16.1, U1.37 (PC6)
NRST: C10.1, J2.6, SW3.1, U1.7 (NRST)
unnamed: D1.2 (A), R7.2
unnamed: D2.2 (A), R9.2
unnamed: D3.1 (K), R10.1
unnamed: D4.2 (A), R11.2
unnamed: D5.2 (A), U2.1 (VBUS)
unnamed: D6.2 (A), R12.2
unnamed: D7.2 (A), LS1.2, Q1.3 (D)
unnamed: D8.2 (A), R16.2
unnamed: D9.2 (A), R17.2
unnamed: J15.4, JP1.1 (A), JP2.1 (A)
unnamed: Q1.1 (G), R14.2, R15.2
unnamed: R2.1, SW1.1
unnamed: R3.2, SW1.2
unnamed: R4.2, SW1.3
unnamed: R5.2, SW1.5
unnamed: R13.1, SW7.3 (C)
unnamed: R6.2, U1.28 (PB2)
unnamed: C6.1, U1.30 (VCAP_1)
unnamed: C17.1, U3.4 (CS)
OSCL_IN: C1.1, U1.3 (PC14), Y1.1 (CRYSTAL_1)
OSCL_OUT: C2.1, U1.4 (PC15), Y1.4 (CRYSTAL_2)
RJ45_3_0: J10.3, J11.3
RJ45_6_0: J10.6, J11.6
SWCLK: J2.4, U1.49 (PA14)
SWDIO: J2.5, U1.46 (PA13)
SWO: J2.3, U1.55 (PB3)
UART3_RX: J3.1, U1.52 (PC11)
UART3_TX: J3.2, U1.51 (PC10)
USR_LED0: R7.1, U1.54 (PD2)
USR_LED1: R9.1, U1.8 (PC0)
USR_LED2: R11.1, U1.9 (PC1)
USR_SW0: C13.1, SW6.1, U1.26 (PB0)
USR_SW1: C12.1, SW5.1, U1.27 (PB1)
USR_SW2: C11.1, SW4.1, U1.2 (PC13)
UnitSelect: R1.2, SW1.6, SW1.7, SW1.8, U1.24 (PC4)
VCP_RX: J2.8, U1.17 (PA3)
VCP_TX: J2.7, U1.16 (PA2)

File OneDrive/ドキュメント/PCB/446RMv1.0-20240913T070430Z-001/446RMv1.0/Parts_446_CAN_Swerve_narrow_panelize.csv:

Comment,Designator,Footprint,LCSC,JLC,ÝÉ,H,Digi,
4.3p,"C1,C2",C_0603_1608Metric,,,,,o,https://www.digikey.jp/ja/products/detail/yageo/CC0603BRNPO9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
0.1u,"C10,C11,C12,C13,C14,C15,C16,C4,C5,C7,C8,C9",C_0603_1608Metric,C14663,o,,,,
1u,C3,C_0603_1608Metric,C15849,o,,,,
4.7u,C6,C_0603_1608Metric,C19666,o,,,,
0.22u,C18,C_0603_1608Metric,C21120,o,,,,
1k,"R10,R12,R9",R_0603_1608Metric,C21190,o,,,,
120R,"R13,R5",R_0603_1608Metric,C22787,o,o,,,
1k5,R1,R_0603_1608Metric,C22843,o,,,,
2.4k,R4,R_0603_1608Metric,C22940,o,,,,
3.3k,R11,R_0603_1608Metric,C22978,o,,,,
5.1k,R3,R_0603_1608Metric,C23186,o,,,,
510R,R7,R_0603_1608Metric,C23193,o,,,,
10k,"R2,R6,R8",R_0603_1608Metric,C25804,o,,,,
0.01u,C17,C_0603_1608Metric,C57112,o,,,,
5V_IO,J4,JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical,,,o,,,
CAN1A,J8,JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal_Handsolder,,,o,,,
CAN_END0,SW7,slide_SW,,,o,,,
USR0,D1,LED_0603_1608Metric,,,,o,,
debug,J2,PinHeader_2x04_P1.27mm_Vertical_SMD,,,,110704,,https://akizukidenshi.com/catalog/g/g110704/
5V_IO,J5,JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical,,,o,,,
LED1,D6,LED_0603_1608Metric,,,,o,,
USR0,SW6,SW_SPST_PTS810_HandSolder,,,o,,,
USR1,D2,LED_0603_1608Metric,,,,o,,
NRST,SW3,SW_SPST_PTS810_HandSolder,,,o,,,
USR2,SW4,SW_SPST_PTS810_HandSolder,,,o,,,
CAN0B,J11,Kai_LAN_RJ45_Neltron_Industrial_7810-8P8C,,,,o,,
3v3_IO,J7,PinHeader_1x02_P2.54mm_Vertical,,,o,,,
STM32F446RETx,U1,LQFP-64_10x10mm_P0.5mm,,,o,,,
UART3,J3,JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical,,,o,,,
CAN1B,J9,JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal_Handsolder,,,o,,,
3v3_IO,J6,PinHeader_1x02_P2.54mm_Vertical,,,o,,,
CAN0A,J10,Kai_LAN_RJ45_Neltron_Industrial_7810-8P8C,,,,o,,
UnitSelect,SW1,SW_DIP_SPSTx04_Slide_KingTek_DSHP04TS_W7.62mm_P1.27mm,,,,108929,,https://akizukidenshi.com/catalog/g/g108929/
BOOT0,SW2,SW_SPST_PTS810_HandSolder,,,o,,,
ABS25-32.768KHZ-6-T,Y1,ABS2532768KHZT,,,,,o,https://www.digikey.jp/ja/products/detail/abracon-llc/ABS25-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
USB_5V,U2,aki_USB_mB_PWR,,,o,,,
5VPWR,D3,LED_0603_1608Metric,,,,o,,
USR2,D4,LED_0603_1608Metric,,,,o,,
ENC0,J1,JST_XA_B05B-XASK-1_1x05_P2.50mm_Vertical,,,o,,,
USR1,SW5,SW_SPST_PTS810_HandSolder,,,o,,,
FerriteBead,FB1,L_0603_1608Metric,,,,,o,https://www.digikey.jp/ja/products/detail/tai-tech-advanced-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
CUHS20S30,D5,D_TUMD2,,,o,,,
NJM12788F33,U3,,,,,115767,,https://akizukidenshi.com/catalog/g/g115767/
MCP2561-E/SN,"U4,U5",,,,o,,,

## KiCad design OneDrive/ドキュメント/PCB/446CAN_2-20240912T023128Z-001/446CAN_2/446CAN_2.kicad_pcb

Board: 2 copper layers, 9 parts (0 on the bottom side), 8 nets.

Parts:
C2: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: PWR; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J3: CAN1A; LAN-DIP_in
J4: CAN1B; LAN-DIP_in
J6: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
R2: 120R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R3: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: NUCLEO-F446RE
U3: MCP2561-E-P; DIP-8_W7.62mm

Connections:
+5V: C2.2, J3.7, J3.8, J4.7, J4.8, R3.1, U1.CN7_18 (CN7_+5V), U3.3 (VDD)
CAN2H: J3.1, J4.1, R2.2, U3.7 (CANH)
CAN2L: J3.2, J4.2, J6.1, U3.6 (CANL)
CAN2_RD: U1.CN10_16 (PB12), U3.4 (RXD)
CAN2_TD: U1.CN10_30 (PB13), U3.1 (TXD)
GND: C2.1, D1.1 (K), J3.4, J3.5, J4.4, J4.5, U1.CN7_8 (CN7_GND), U1.CN7_19 (CN7_GND), U1.CN7_20 (CN7_GND), U1.CN7_22 (CN7_GND), U1.CN10_9 (CN10_GND), U1.CN10_20 (CN10_GND), U3.2 (VSS), U3.8 (STBY)
unnamed: D1.2 (A), R3.2
unnamed: J6.2, R2.1

## KiCad design OneDrive/ドキュメント/PCB/303_MCv3_6-20240912T023711Z-001/303_MCv3_6/303_MCv3_6.kicad_pcb

Parts:
C1: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D6: Yellow; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2: PA6; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3: PA1; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D4: PA7; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5: PA3; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D7: USR1; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D8: USR2; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D9: USR3; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D10: PWR; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D11: CUHS20S30; D_TUMD2
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad
J1: PA5; PinHeader_1x02_P2.54mm_Vertical
J2: PA5; JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical
J3: ENC2; JST_XA_B05B-XASK-1_1x05_P2.50mm_Vertical
J4: ENC1; JST_XA_B05B-XASK-1_1x05_P2.50mm_Vertical
J5: Motor1; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J6: Motor2; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J7: PA0; PinHeader_1x02_P2.54mm_Vertical
J8: PA0; JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical
J9: CAN1A; Kai_LAN_RJ45_Neltron_Industrial_7810-8P8C
J10: CAN1B; Kai_LAN_RJ45_Neltron_Industrial_7810-8P8C
J11, J16: 5V_IO; JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical
J12, J18: CAN; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal_Handsolder
J13, J17: 3v3_IO; PinHeader_1x02_P2.54mm_Vertical
J14: Int1; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J15: Int2; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
JP1: PA5; solderbridge
JP2: PA6; solderbridge
JP3: PA1; solderbridge
JP4: PA7; solderbridge
JP5: PA3; solderbridge
JP6: PA0; solderbridge
JP7: USR1; solderbridge
JP8: USR2; solderbridge
JP9: USR3; solderbridge
JP10: PA1-Buz; solderbridge
JP11: 5v-Buz; solderbridge
JP12: NRST-3V3; solderbridge
LS1: UGCT7525AN4
Q1: 2N7002K; SOT-23
R1, R6, R7, R8, R9: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R3: 3k3; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R5: 500R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R10: 120R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R12: 200R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R13: 2K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R14: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: USR1; SW_SPST_PTS810_HandSolder
SW2: USR2; SW_SPST_PTS810_HandSolder
SW3: USR3; SW_SPST_PTS810_HandSolder
SW4: SW_DPDT_x2; slide_SW
SW5: NRST; SW_SPST_PTS810_HandSolder
U1: NUCLEO-F303K8; MODULE_NUCLEO-F303K8; PARTREV 5
U2: MCP2561-E-P; DIP-8_W7.62mm

Connections:
+3V3: J13.2, J17.2, JP12.1 (A), U1.4_14 (+3V3)
+5V: C1.2, J3.4, J4.4, J9.7, J9.8, J10.7, J10.8, J11.2, J14.2, J15.2, J16.2, JP11.1 (A), R11.1, U1.4_4 (+5V), U2.3 (VDD)
BUZZER: J6.2, JP3.1 (A), JP10.1 (A), U1.4_11 (PA1)
CANH: J9.1, J10.1, J12.2, J18.2, R10.2, U2.7 (CANH)
CANL: J9.2, J10.2, J12.1, J18.1, SW4.2 (B), U2.6 (CANL)
CAN_RD: U1.3_13 (PA11), U2.4 (RXD)
CAN_TD: U1.3_5 (PA12), U2.1 (TXD)
ENC1A_PA9: J4.3, U1.3_1 (PA9)
ENC1B_PA8: J4.5, U1.3_12 (PA8)
ENC2A_PB5: J3.3, U1.3_14 (PB5)
ENC2B_PB4: J3.5, U1.3_15 (PB4)
GND: C1.1, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), H1.1, H2.1, H3.1, H4.1, J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.4, J9.5, J10.4, J10.5, J11.1, J13.1, J14.1, J15.1, J16.1, J17.1, Q1.2 (S), R13.1, SW1.2, SW2.2, SW3.2, SW5.2, U1.3_4 (GND_1), U1.4_2 (GND_2), U2.2 (VSS), U2.8 (STBY)
GPIO_PA0: J7.2, J8.2, J14.3, JP6.1 (A), U1.4_12 (PA0)
GPIO_PA5: J1.2, J2.2, J15.3, JP1.1 (A), U1.4_8 (PA5)
Motor1A_PA6: J5.2, JP2.1 (A), U1.4_7 (PA6)
Motor1B_PA7: J5.3, JP4.1 (A), U1.4_6 (PA7)
Motor2B_PA3: J6.3, JP5.1 (A), U1.4_10 (PA3)
NRST: R14.1, SW5.1, U1.4_3 (NRST_2)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), R4.2
unnamed: D5.2 (A), R5.2
unnamed: D6.2 (A), R6.2
unnamed: D7.2 (A), R7.2
unnamed: D8.2 (A), R8.2
unnamed: D9.2 (A), R9.2
unnamed: D10.2 (A), R11.2
unnamed: D11.1 (K), JP11.2 (B), LS1.1
unnamed: D11.2 (A), LS1.2, Q1.3 (D)
unnamed: JP1.2 (B), R1.1
unnamed: JP2.2 (B), R2.1
unnamed: JP3.2 (B), R3.1
unnamed: JP4.2 (B), R4.1
unnamed: JP5.2 (B), R5.1
unnamed: JP6.2 (B), R6.1
unnamed: JP7.2 (B), R7.1
unnamed: JP8.2 (B), R8.1
unnamed: JP9.2 (B), R9.1
unnamed: JP10.2 (B), R12.1
unnamed: JP12.2 (B), R14.2
unnamed: Q1.1 (G), R12.2, R13.2
unnamed: R10.1, SW4.3 (C)
RJ45_3: J9.3, J10.3
RJ45_6: J9.6, J10.6
USR_LED1: JP7.1 (A), U1.3_6 (PB0)
USR_LED2: JP8.1 (A), U1.3_9 (PB1)
USR_LED3: JP9.1 (A), U1.4_9 (PA4)
USR_SW1: SW1.1, U1.3_2 (PA10)
USR_SW2: SW2.1, U1.3_10 (PF0)
USR_SW3: SW3.1, U1.3_11 (PF1)

Notes on the sheet:
専用 ENC1>TIM1-ch1.ch2>PA8,PA9 ENC2>TIM3-ch1,ch2>PB4,PB5 Motor1>TIM15-ch2,ch1N>PA3,PA1 Motor2>TIM16-1,TIM17-1>,PA6,PA7 CAN>TD,RD>PA12,PA11
排他 PA5[A4]<->PB7[D4] PA6[A5]<->PB6[D5] SB16,SB18を外さなければ、A4,A5をI2Cとして使用できる

Board: 2 copper layers, 72.4 x 47.3 mm, 69 parts (12 on the bottom side), 51 nets.

File OneDrive/ドキュメント/PCB/303_MCv3_6-20240912T023711Z-001/303_MCv3_6/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1_2, C1",0805,2,0.1u,
"D1_2, D1, D6_2, D6",0603,4,Yellow,
"D10_2, D10",0603,2,PWR,
"D11_2, D11",D_TUMD2,2,CUHS20S30,
"D2_2, D2",0603,2,PA6,
"D3_2, D3",0603,2,PA1,
"D4_2, D4",0603,2,PA7,
"D5_2, D5",0603,2,PA3,
"D7_2, D7",0603,2,USR1,
"D8_2, D8",0603,2,USR2,
"D9_2, D9",0603,2,USR3,
"H1_2, H1, H2_2, H2, H3_2, H3, H4_2, H4",MountingHole_3.2mm_M3_DIN965_Pad,8,MountingHole_Pad,
"J1_2, J1",PinHeader_1x02_P2.54mm_Vertical,2,PA5,
"J10_2, J10",Kai_LAN_RJ45_Neltron_Industrial_7810-8P8C,2,CAN1B,
"J11_2, J11, J16_2, J16",JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical,4,5V_IO,
"J12_2, J12, J18_2, J18",JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal_Handsolder,4,CAN,
"J13_2, J13, J17_2, J17",PinHeader_1x02_P2.54mm_Vertical,4,3v3_IO,
"J14_2, J14",JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical,2,Int1,
"J15_2, J15",JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical,2,Int2,
"J2_2, J2",JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical,2,PA5,
"J3_2, J3",JST_XA_B05B-XASK-1_1x05_P2.50mm_Vertical,2,ENC2,
"J4_2, J4",JST_XA_B05B-XASK-1_1x05_P2.50mm_Vertical,2,ENC1,
"J5_2, J5",JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical,2,Motor1,
"J6_2, J6",JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical,2,Motor2,
"J7_2, J7",PinHeader_1x02_P2.54mm_Vertical,2,PA0,
"J8_2, J8",JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical,2,PA0,
"J9_2, J9",Kai_LAN_RJ45_Neltron_Industrial_7810-8P8C,2,CAN1A,
"JP1_2, JP1",solderbridge,2,PA5,
"JP10_2, JP10",solderbridge,2,PA1-Buz,
"JP11_2, JP11",solderbridge,2,5v-Buz,
"JP12_2, JP12",solderbridge,2,NRST-3V3,
"JP2_2, JP2",solderbridge,2,PA6,
"JP3_2, JP3",solderbridge,2,PA1,
"JP4_2, JP4",solderbridge,2,PA7,
"JP5_2, JP5",solderbridge,2,PA3,
"JP6_2, JP6",solderbridge,2,PA0,
"JP7_2, JP7",solderbridge,2,USR1,
"JP8_2, JP8",solderbridge,2,USR2,
"JP9_2, JP9",solderbridge,2,USR3,
"LS1_2, LS1",UGCT7525AN4,2,UGCT7525AN4,
"Q1_2, Q1",SOT-23,2,2N7002K,
"R1_2, R1, R11_2, R11, R6_2, R6, R7_2, R7, R8_2, R8, R9_2, R9",0805,12,1k,
"R10_2, R10",0805,2,120R,
"R12_2, R12",0805,2,200R,
"R13_2, R13",0805,2,2K,
"R14_2, R14",0805,2,100R,
"R2_2, R2, R3_2, R3",0805,4,3k3,
"R4_2, R4, R5_2, R5",0805,4,500R,
"SW1_2, SW1",SW_SPST_PTS810_HandSolder,2,USR1,
"SW2_2, SW2",SW_SPST_PTS810_HandSolder,2,USR2,
"SW3_2, SW3",SW_SPST_PTS810_HandSolder,2,USR3,
"SW4_2, SW4",slide_SW,2,SW_DPDT_x2,
"SW5_2, SW5",SW_SPST_PTS810_HandSolder,2,NRST,
"U1_2, U1",MODULE_NUCLEO-F303K8,2,NUCLEO-F303K8,
"U2_2, U2",DIP-8_W7.62mm,2,MCP2561-E-P,

## Commit log

2025-12-15 Rename can.readme to can.md
